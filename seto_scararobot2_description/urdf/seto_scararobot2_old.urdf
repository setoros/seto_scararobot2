Commit message: 20210905

File: seto_scararobot2_description/urdf/seto_scararobot2_old.urdf (robot description, URDF)
Before this commit: robot seto_scararobot, 7 links, 6 joints
Links:
- removed link ee1
- removed link ee2
Joints:
- removed joint ee1_joint
- removed joint ee2_joint
